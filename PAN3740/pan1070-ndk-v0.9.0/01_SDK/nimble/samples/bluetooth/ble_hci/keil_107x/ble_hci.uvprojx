# Keil uVision project ble_hci.uvprojx, settings and files
target ble_hci (5060750::V5.06 update 6 (build 750)::ARMCC)
  device: ARMCM0 ARM
  pack: ARM.CMSIS.5.7.0
  cpu: IRAM(0x20000000,0x00020000) IROM(0x00000000,0x00040000) CPUTYPE("Cortex-M0") CLOCK(12000000) ESEL ELITTLE
  output: ble_hci +hex
  BeforeMake: $J\..\bin\armcc.exe -P "$Pconfiguration\sdk_config.h"
  AfterMake: post_build.bat ".\Images" "$P" "#L" "#H" "$J\..\bin\fromelf.exe"
  AfterMake: python.exe ../../../../scripts/flash_ram_usage.py ./Listings/@L.map
  c flags: Optim=4 oTime=1 OneElfS=1 uC99=1 uGnu=1 v6Lang=4 v6LangP=4 wLevel=2
  c define: IP_107x, CONFIG_FLASH_LINE_MODE=FLASH_X4_MODE, BLE_HCI_PROJ_EN=1
  c misc: --preinclude=soc_config.h
  c include: ..\..\..\..\..\modules\hal\panchip\panplat\pan1070\bsp\cmsis\include;..\..\..\..\..\modules\hal\panchip\panplat\pan1070\bsp\peripheral\inc;..\..\..\..\..\modules\hal\panchip\panplat\pan1070\bsp\device\Include;..\..\..\..\..\modules\hal\panchip\panplat\pan1070\bsp\radio\prf_lib\include;..\..\..\..\..\modules\hal\panchip\panplat\pan1070\bsp\SEGGER_RTT\RTT;..\..\..\..\os\freertos\include;..\..\..\..\os\freertos\portable\RVDS\ARM_CM0;..\..\..\..\host;..\..\..\..\host\nimble\ext\tinycrypt\include;..\..\..\..\host\nimble\nimble\include;..\..\..\..\host\nimble\nimble\host\include;..\..\..\..\host\nimble\nimble\host\util\include;..\..\..\..\host\nimble\nimble\transport\include;..\..\..\..\host\nimble\porting\nimble\include;..\..\..\..\host\nimble\porting\npl\freertos\include;..\..\..\..\host\nimble\nimble\host\services\gap\include;..\..\..\..\host\nimble\nimble\host\services\gatt\include;..\..\..\..\host\nimble\nimble\host\store\ram\include;..\..\..\..\host\nimble\nimble\host\store\config\include;..\..\..\..\host\nimble\ext\base64\include;..\..\..\..\controller\pan107x_spark\include;..\..\..\..\controller\rf_test;..\..\..\..\config;..\..\..\..\component\app_log;..\..\..\..\component\kv_store;..\..\..\..\soc;..\..\..\..\utilities;.\configuration;..\src;..\..\..\..\host\nimble\nimble\transport\common\hci_h4\include
  library: MicroLIB
  memory RVCT4: ROM 0x0 size 0x40000
  memory RVCT9: RAM 0x20000000 size 0x10000
  scatter file: .\project.sct
  link misc: --entry Reset_Handler --any_placement=best_fit
  group cmsis
    ../../../../../modules/hal/panchip/panplat/pan1070/bsp/device/Source/: system_PANSeries.c
    ./startup/: startup_PANSeries.s
  group drivers
    ../../../../../modules/hal/panchip/panplat/pan1070/bsp/peripheral/src/: pan_adc.c pan_dmac.c pan_fmc.c pan_gpio.c pan_i2c.c pan_pwm.c pan_spi.c pan_timer.c pan_uart.c pan_wdt.c pan_wwdt.c pan_hal.c pan_hal_adc.c pan_hal_dmac.c pan_hal_gpio.c pan_hal_i2c.c pan_hal_pwm.c pan_hal_spi.c pan_hal_timer.c pan_hal_uart.c pan_hal_wdt.c pan_hal_wwdt.c
    ../../../../../modules/hal/panchip/panplat/pan1070/bsp/device/Source/: pan_clk.c pan_clktrim.c pan_lp.c pan_power.c pan_sys.c
  group soc
    ../../../../soc/: soc.c soc_32k_cali.c soc_pm.c soc_api.h
  group soc_misc
    ../../../../../modules/hal/panchip/panplat/pan1070/bsp/device/Source/: retarget.c simple_print.c cbprintf_nano.c printk.c
    ../../../../../modules/hal/panchip/panplat/pan1070/bsp/SEGGER_RTT/RTT/: SEGGER_RTT.c
  group freertos_kernel
    ../../../../os/freertos/: event_groups.c list.c queue.c stream_buffer.c tasks.c timers.c
  group freertos_porting
    ../../../../os/freertos/portable/RVDS/ARM_CM0/: port.c
    ../../../../os/freertos/portable/MemMang/: heap_4.c
    ../../../../os/freertos/portable/RVDS/ARM_CM0/pan107x/: os_setup.c os_lp.c
  group ble_hci_transport
    ../../../../host/nimble/porting/nimble/src/: endian.c mem.c nimble_port.c os_mbuf.c os_mempool.c os_msys_init.c
    ../../../../host/nimble/porting/npl/freertos/src/: npl_os_freertos.c
    ../../../../host/nimble/nimble/transport/src/: transport.c monitor.c
    ../../../../host/nimble/nimble/transport/common/hci_h4/src/: hci_h4.c
    ../../../../host/: pan_spark_glue.c pan_spark_glue.h
  group lib
    ../../../../lib/pan107x_spark/: ble_spark_107x.lib
  group app_log
    ../../../../component/app_log/: app_log.c app_log.h app_log_uart.c app_track.c
  group utilities
    ../../../../utilities/: pan_mac_addr.c utility.c os_wrapper.c xcritical.c bytes.c utility.h
  group config
    ./configuration/: sdk_config.h
  group user
    ../src/: main.c app.c app.h app_hci_uart.c
