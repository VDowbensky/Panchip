# Keil uVision project bootloader.uvprojx, settings and files
target BootLoader (5060750::V5.06 update 6 (build 750)::ARMCC)
  device: ARMCM0 ARM
  pack: ARM.CMSIS.5.7.0
  cpu: IRAM(0x20000000,0x00020000) IROM(0x00000000,0x00040000) CPUTYPE("Cortex-M0") CLOCK(12000000) ESEL ELITTLE
  output: bootloader +hex
  BeforeMake: $J\..\bin\armcc.exe -P "$Pconfiguration\sdk_config.h"
  AfterMake: post_build.bat .\Images @L #L #H "$J\..\bin\fromelf.exe"
  AfterMake: python.exe ../../scripts/flash_ram_usage.py ./Listings/@L.map
  c flags: Optim=4 OneElfS=1 uC99=1 uGnu=1 v6Lang=3 v6LangP=5 wLevel=2
  c define: IS_BOOTLOADER=1, CONFIG_FLASH_LINE_MODE=FLASH_X4_MODE, BLE_EN=0, CONFIG_OS_EN=0
  c misc: --preinclude=soc_config.h
  c include: ..\..\..\modules\hal\panchip\panplat\pan1070\bsp\cmsis\include;..\..\..\modules\hal\panchip\panplat\pan1070\bsp\peripheral\inc;..\..\..\modules\hal\panchip\panplat\pan1070\bsp\device\Include;..\..\..\modules\hal\panchip\panplat\pan1070\bsp\radio\prf_lib\include;..\..\..\modules\hal\panchip\panplat\pan1070\bsp\SEGGER_RTT\RTT;..\..\os\freertos\include;..\..\os\freertos\portable\RVDS\ARM_CM0;..\..\config;..\..\component\app_log;..\..\soc;..\..\utilities;.\configuration;..\src;..\src\usb
  library: MicroLIB
  memory RVCT4: ROM 0x0 size 0xa000
  memory RVCT9: RAM 0x20000000 size 0x10000
  scatter file: .\project.sct
  link misc: --entry Reset_Handler
  group cmsis
    ../../../modules/hal/panchip/panplat/pan1070/bsp/device/Source/arm/: startup_PANSeries.s
    ../../../modules/hal/panchip/panplat/pan1070/bsp/device/Source/: system_PANSeries.c
  group drivers
    ../../../modules/hal/panchip/panplat/pan1070/bsp/peripheral/src/: pan_adc.c pan_dmac.c pan_fmc.c pan_gpio.c pan_i2c.c pan_pwm.c pan_spi.c pan_timer.c pan_uart.c pan_wdt.c pan_wwdt.c pan_hal.c pan_hal_adc.c pan_hal_dmac.c pan_hal_gpio.c pan_hal_i2c.c pan_hal_pwm.c pan_hal_spi.c pan_hal_timer.c pan_hal_uart.c pan_hal_wdt.c pan_hal_wwdt.c
    ../../../modules/hal/panchip/panplat/pan1070/bsp/device/Source/: pan_clk.c pan_clktrim.c pan_efuse.c pan_lp.c pan_power.c pan_sys.c
  group soc
    ../../soc/: soc.c soc_32k_cali.c soc_api.h
  group soc_misc
    ../../../modules/hal/panchip/panplat/pan1070/bsp/device/Source/: retarget.c simple_print.c cbprintf_nano.c printk.c
    ../../../modules/hal/panchip/panplat/pan1070/bsp/SEGGER_RTT/RTT/: SEGGER_RTT.c
  group lib
    ../../../modules/hal/panchip/panplat/pan1070/bsp/radio/prf_lib/: prf_lib.lib
    ../../../modules/hal/panchip/panplat/pan1070/bsp/radio/src/: pan_prf_glue.c
  group app_log
    ../../component/app_log/: app_log.c app_log_uart.c app_track.c
  group utilities
    ../../utilities/: utility.c utility.h bytes.c bytes.h
  group pan_usb
    ../src/usb/: endpoint.c endpoint0.c musbfsfc.c usb_panchip.c
  group config
    ./configuration/: sdk_config.h
  group user
    ../src/: main.c flash_manager.c signal_slot_manager.c signal.c uart_dfu.c usb_dfu.c prf_ota.c
