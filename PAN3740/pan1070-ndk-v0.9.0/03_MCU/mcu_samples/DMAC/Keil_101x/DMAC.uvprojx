# Keil uVision project DMAC.uvprojx, settings and files
target ASIC (5060750::V5.06 update 6 (build 750)::ARMCC)
  device: ARMCM0 ARM
  pack: ARM.CMSIS.5.7.0
  cpu: IRAM(0x20000000,0x00020000) IROM(0x00000000,0x00040000) CPUTYPE("Cortex-M0") CLOCK(12000000) ESEL ELITTLE
  output: DMAC +hex
  c flags: Optim=3 OneElfS=1 uC99=1 uGnu=1 v6Lang=4 v6LangP=4 wLevel=2
  c define: CONFIG_FLASH_LINE_MODE=1,IP_101x,CONFIG_UART_LOG_ENABLE
  c include: ..\..\..\..\01_SDK\modules\hal\panchip\panplat\pan1070\bsp\cmsis\include;..\..\..\..\01_SDK\modules\hal\panchip\panplat\pan1070\bsp\peripheral\inc;..\..\..\..\01_SDK\modules\hal\panchip\panplat\pan1070\bsp\device\Include;..\src;..\..\..\..\01_SDK\modules\hal\panchip\panplat\pan1070\bsp\radio\prf_lib\include
  library: MicroLIB
  memory RVCT4: ROM 0x0 size 0x40000
  memory RVCT9: RAM 0x20000000 size 0x20000
  link misc: --entry Reset_Handler
  group CMSIS
    ../../../../01_SDK/modules/hal/panchip/panplat/pan1070/bsp/device/Source/: system_PANSeries.c
    ../../../../01_SDK/modules/hal/panchip/panplat/pan1070/bsp/device/Source/arm/: startup_PANSeries.s
  group Library
    ../../../../01_SDK/modules/hal/panchip/panplat/pan1070/bsp/peripheral/src/: pan_adc.c pan_dmac.c pan_fmc.c pan_gpio.c pan_i2c.c pan_pwm.c pan_spi.c pan_timer.c pan_uart.c pan_wdt.c pan_wwdt.c
  group Device
    ../../../../01_SDK/modules/hal/panchip/panplat/pan1070/bsp/device/Source/: retarget.c pan_clk.c pan_lp.c pan_sys.c
  group User
    ../src/: dma_1byte_tfr.c dma_2channel_tfr.c dma_3channel_tfr.c dma_4092byte_tfr.c dma_common.c dma_hardware_multiblock.c dma_iic2spi.c dma_lock_bus.c dma_lock_channel.c dma_lock_channel_bus.c dma_mem2mem.c dma_multi_channel_block.c dma_multiblock.c dma_priority.c dma_spi2uart.c dma_uart2iic.c i2c_dma_m2p.c i2c_dma_p2m.c main.c spi_dma_full_duplex.c spi_dma_m2p.c spi_dma_m2p_gather.c spi_dma_m2p1.c spi_dma_m2p2.c spi_dma_p2m.c spi_dma_p2m_scater.c spi_dma_p2m1.c spi_dma_p2m2.c uart_dma_m2p.c uart_dma_p2m.c flash_dma_f2p.c
