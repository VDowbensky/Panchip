# Keil uVision project GPIO.uvprojx, settings and files
target ASIC (5060750::V5.06 update 6 (build 750)::ARMCC)
  device: ARMCM0 ARM
  pack: ARM.CMSIS.5.7.0
  cpu: IRAM(0x20000000,0x00020000) IROM(0x00000000,0x00040000) CPUTYPE("Cortex-M0") CLOCK(12000000) ESEL ELITTLE
  output: GPIO +hex
  AfterMake: cmd.exe /c $J\..\bin\fromelf.exe --bin -o "bin/@L.bin" "#L" && $J\..\bin\fromelf.exe -acd --interleave=source -o "bin/@L.disasm" "#L"
  c flags: Optim=4 OneElfS=1 uC99=1 uGnu=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: CONFIG_FLASH_LINE_MODE=1,IP_101x,CONFIG_UART_LOG_ENABLE
  c include: ..\..\..\..\01_SDK\modules\hal\panchip\panplat\pan1070\bsp\cmsis\include;..\..\..\..\01_SDK\modules\hal\panchip\panplat\pan1070\bsp\peripheral\inc;..\..\..\..\01_SDK\modules\hal\panchip\panplat\pan1070\bsp\device\Include;..\src;..\..\..\..\01_SDK\modules\hal\panchip\panplat\pan1070\bsp\radio\prf_lib\include
  library: MicroLIB
  memory RVCT4: ROM 0x0 size 0x40000
  memory RVCT9: RAM 0x20000000 size 0xc000
  link misc: --entry Reset_Handler
  group CMSIS
    ../../../../01_SDK/modules/hal/panchip/panplat/pan1070/bsp/device/Source/: system_PANSeries.c
    ../../../../01_SDK/modules/hal/panchip/panplat/pan1070/bsp/device/Source/arm/: startup_PANSeries.s
  group Device
    ../../../../01_SDK/modules/hal/panchip/panplat/pan1070/bsp/device/Source/: pan_sys.c pan_clk.c pan_lp.c
  group Peripheral
    ../../../../01_SDK/modules/hal/panchip/panplat/pan1070/bsp/peripheral/src/: pan_gpio.c pan_uart.c pan_fmc.c
  group Misc
    ../../../../01_SDK/modules/hal/panchip/panplat/pan1070/bsp/device/Source/: retarget.c
  group User
    ../src/: main.c gpio_common.c gpio_push_pull_mode_test.c gpio_open_drain_mode_test.c gpio_quasi_bidirectional_mode_test.c gpio_debounce_test.c gpio_interrupt_test.c gpio_wakeup_test.c gpio_dout_write_mask_test.c
