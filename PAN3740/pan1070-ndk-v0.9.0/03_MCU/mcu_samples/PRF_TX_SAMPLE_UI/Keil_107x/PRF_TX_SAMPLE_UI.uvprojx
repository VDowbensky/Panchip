# Keil uVision project PRF_TX_SAMPLE_UI.uvprojx, settings and files
target Tx_xn297_1M (5060750::V5.06 update 6 (build 750)::ARMCC)
  device: ARMCM0 ARM
  pack: ARM.CMSIS.5.9.0
  cpu: IRAM(0x20000000,0x00020000) IROM(0x00000000,0x00040000) CPUTYPE("Cortex-M0") CLOCK(12000000) ESEL ELITTLE
  output: Tx_xn297_1M +hex
  c flags: Optim=1 OneElfS=1 uC99=1 uGnu=1 v6Lang=3 v6LangP=3 wLevel=2
  c define: CONFIG_FLASH_LINE_MODE=FLASH_X4_MODE,CONFIG_UART_LOG_ENABLE
  c include: ..\..\..\..\01_SDK\modules\hal\panchip\panplat\pan1070\bsp\device\Include;..\..\..\..\01_SDK\modules\hal\panchip\panplat\pan1070\bsp\peripheral\inc;..\..\..\..\01_SDK\modules\hal\panchip\panplat\pan1070\bsp\cmsis\include;..\src;..\..\..\..\01_SDK\modules\hal\panchip\panplat\pan1070\bsp\radio\prf_lib\include
  library: MicroLIB
  memory RVCT4: ROM 0x0 size 0x40000
  memory RVCT9: RAM 0x20000000 size 0x10000
  scatter file: .\custom.sct
  link misc: --entry Reset_Handler
  group CMSIS
    ../../../../01_SDK/modules/hal/panchip/panplat/pan1070/bsp/device/Source/: system_PANSeries.c
    ../../../../01_SDK/modules/hal/panchip/panplat/pan1070/bsp/device/Source/arm/: startup_PANSeries.s
  group drivers
    ../../../../01_SDK/modules/hal/panchip/panplat/pan1070/bsp/device/Source/: pan_clk.c pan_clktrim.c pan_sys.c retarget.c
    ../../../../01_SDK/modules/hal/panchip/panplat/pan1070/bsp/peripheral/src/: pan_adc.c pan_dmac.c pan_fmc.c pan_gpio.c pan_i2c.c pan_pwm.c pan_spi.c pan_timer.c pan_uart.c pan_wdt.c pan_wwdt.c
  group prf
    ../../../../01_SDK/modules/hal/panchip/panplat/pan1070/bsp/radio/src/: pan_prf_glue.c
  group User
    ../src/: main.c lcd_ui.c lcd_matrix.c lcd_view_ctrl.c tft_lcd_128x160.c
    ../../../../01_SDK/modules/hal/panchip/panplat/pan1070/bsp/radio/prf_lib/: prf_lib.lib
  group config
    ../src/: sample_config.h
