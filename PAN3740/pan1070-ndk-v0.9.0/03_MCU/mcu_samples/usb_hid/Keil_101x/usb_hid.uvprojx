# Keil uVision project usb_hid.uvprojx, settings and files
target ASIC (5060750::V5.06 update 6 (build 750)::ARMCC)
  device: ARMCM0 ARM
  pack: ARM.CMSIS.5.7.0
  cpu: IRAM(0x20000000,0x00020000) IROM(0x00000000,0x00040000) CPUTYPE("Cortex-M0") CLOCK(12000000) ESEL ELITTLE
  output: USB_HID +hex
  c flags: Optim=1 OneElfS=1 uC99=1 uGnu=1 v6Lang=4 v6LangP=4 wLevel=2
  c define: CONFIG_FLASH_LINE_MODE=1,IP_101x,CONFIG_UART_LOG_ENABLE
  c include: ..\..\..\..\01_SDK\modules\hal\panchip\panplat\pan1070\bsp\cmsis\include;..\..\..\..\01_SDK\modules\hal\panchip\panplat\pan1070\bsp\peripheral\inc;..\..\..\..\01_SDK\modules\hal\panchip\panplat\pan1070\bsp\device\Include;..\src;..\..\..\..\01_SDK\modules\hal\panchip\panplat\pan1070\bsp\radio\prf_lib\include;..\..\..\..\01_SDK\modules\hal\panchip\panplat\pan1070\bsp\usb
  library: MicroLIB
  memory RVCT4: ROM 0x0 size 0x40000
  memory RVCT9: RAM 0x20000000 size 0x20000
  link misc: --entry Reset_Handler
  group CMSIS
    ../../../../01_SDK/modules/hal/panchip/panplat/pan1070/bsp/device/Source/: system_PANSeries.c
    ../../../../01_SDK/modules/hal/panchip/panplat/pan1070/bsp/device/Source/arm/: startup_PANSeries.s
  group Device
    ../../../../01_SDK/modules/hal/panchip/panplat/pan1070/bsp/device/Source/: pan_clk.c pan_sys.c
  group Peripheral
    ../../../../01_SDK/modules/hal/panchip/panplat/pan1070/bsp/peripheral/src/: pan_fmc.c pan_gpio.c pan_timer.c pan_uart.c pan_dmac.c
  group Misc
    ../../../../01_SDK/modules/hal/panchip/panplat/pan1070/bsp/device/Source/: retarget.c
  group User
    ../src/: main.c desc.c musbfsfc.c
  group Usb
    ../../../../01_SDK/modules/hal/panchip/panplat/pan1070/bsp/usb/: endpoint.c endpoint0.c usb.c
