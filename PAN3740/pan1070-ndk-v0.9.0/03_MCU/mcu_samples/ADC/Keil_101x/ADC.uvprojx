# Keil uVision project ADC.uvprojx, settings and files
target ASIC (5060750::V5.06 update 6 (build 750)::ARMCC)
  device: ARMCM0 ARM
  pack: ARM.CMSIS.5.7.0
  cpu: IRAM(0x20000000,0x00020000) IROM(0x00000000,0x00040000) CPUTYPE("Cortex-M0") CLOCK(12000000) ESEL ELITTLE
  output: ADC +hex
  AfterMake: fromelf -acd --interleave=source -o "$L@L.disasm" "#L"
  c flags: Optim=1 uC99=1 uGnu=1 v6Lang=4 v6LangP=4 wLevel=2
  c define: CONFIG_FLASH_LINE_MODE=1,IP_101x,CONFIG_UART_LOG_ENABLE
  c include: ..\..\..\..\01_SDK\modules\hal\panchip\panplat\pan1070\bsp\cmsis\include;..\..\..\..\01_SDK\modules\hal\panchip\panplat\pan1070\bsp\device\Include;..\..\..\..\01_SDK\modules\hal\panchip\panplat\pan1070\bsp\peripheral\inc;..\..\..\..\01_SDK\modules\hal\panchip\panplat\pan1070\bsp\radio\prf_lib\include;..\src
  library: MicroLIB
  memory RVCT4: ROM 0x0 size 0x80000
  memory RVCT9: RAM 0x20000000 size 0x8000
  link misc: --entry Reset_Handler --diag_suppress=L6969W
  group CMSIS
    ../../../../01_SDK/modules/hal/panchip/panplat/pan1070/bsp/device/Source/: system_PANSeries.c
    ../../../../01_SDK/modules/hal/panchip/panplat/pan1070/bsp/device/Source/arm/: startup_PANSeries.s
  group Library
    ../../../../01_SDK/modules/hal/panchip/panplat/pan1070/bsp/peripheral/src/: pan_adc.c pan_dmac.c pan_fmc.c pan_gpio.c pan_pwm.c pan_uart.c pan_timer.c
  group Device
    ../../../../01_SDK/modules/hal/panchip/panplat/pan1070/bsp/device/Source/: pan_clk.c pan_sys.c retarget.c
  group User
    ../src/: main.c adc_common.c adc_default_value.c adc_convert_test.c adc_externel_trigger_test.c adc_compare_test.c adc_pwm_sequential_test.c adc_temperature_test.c adc_pwm_seq_one_ch_test.c adc_data_left_shift_test.c adc_convert_test_ch_vbg.c adc_convert_test_ch_vdd_4.c
