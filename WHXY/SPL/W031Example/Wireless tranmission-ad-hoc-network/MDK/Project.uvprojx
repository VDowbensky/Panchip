# Keil uVision project Project.uvprojx, settings and files
target Project (5060750::V5.06 update 6 (build 750)::.\ARMCC)
  device: CW32W031R8 WHXY
  pack: WHXY.CW32W031_DFP.1.0.1
  cpu: IRAM(0x20000000,0x02000) IROM(0x00000000,0x10000) CPUTYPE("Cortex-M0+") CLOCK(12000000) ELITTLE
  output: Project +hex
  c flags: Optim=1 OneElfS=1 uC99=1 v6Lang=5 wLevel=2
  c include: ..\..\..\Libraries\inc;..\..\..\IdeSupport\MDK;..\..\..\Utilities;..\MDK;..\USER\inc;..\Tools;..\RF\inc;..\Protocol;..\SYS\inc
  library: MicroLIB
  memory RVCT4: ROM 0x0 size 0x10000
  memory RVCT9: RAM 0x20000000 size 0x2000
  link misc: --keep=*Handler
  group Startup
    ../../../IdeSupport/MDK/: startup_cw32w031.s
    ../../../Libraries/src/: system_cw32w031.c
  group User
    ../USER/src/: main.c interrupts_cw32w031.c cw32w031bios.c
    ./: uart_fifo.c led_light.c
  group Driver
    ../../../Libraries/src/: cw32w031_adc.c cw32w031_gpio.c cw32w031_gtim.c cw32w031_flash.c cw32w031_rcc.c cw32w031_spi.c cw32w031_systick.c cw32w031_uart.c cw32w031_rtc.c
  group Sys
    ../SYS/src/: delay.c
  group Rf
    ../RF/src/: pan3028.c radio.c pan3028_port.c
  group Doc
    ../: readme.txt
  group Protocol
    ../Protocol/: chirp_networks.c
  group Tools
    ../Tools/: userlog.c xcmd.c
    ./: xcmd_default.c xcmd_key.c
software components: CMSIS:CORE 5.4.0
