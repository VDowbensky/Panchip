# Keil uVision project Project.uvprojx, settings and files
target Project (6230000::V6.23::ARMCLANG)
  device: CW32W031R8 WHXY
  pack: WHXY.CW32W031_DFP.1.0.0
  cpu: IRAM(0x20000000,0x02000) IROM(0x00000000,0x10000) CPUTYPE("Cortex-M0+") CLOCK(12000000) ELITTLE
  output: Project +hex
  c flags: Optim=2 OneElfS=1 uC99=1 uGnu=1 v6Lang=3 v6LangP=3 wLevel=3
  c include: ..\..\..\Libraries\inc;..\..\..\IdeSupport\MDK;..\USER\inc;..\SYS\inc;..\RF\inc;..\OLED\inc
  library: MicroLIB
  memory RVCT4: ROM 0x0 size 0x10000
  memory RVCT9: RAM 0x20000000 size 0x2000
  link misc: --keep=*Handler
  group Startup
    ../../../IdeSupport/MDK/: startup_cw32w031.s
    ../../../Libraries/src/: system_cw32w031.c
  group User
    ../USER/src/: main.c interrupts_cw32w031.c cw32w031bios.c
  group Driver
    ../../../Libraries/src/: cw32w031_adc.c cw32w031_gpio.c cw32w031_gtim.c cw32w031_flash.c cw32w031_rcc.c cw32w031_spi.c cw32w031_systick.c cw32w031_uart.c
  group Sys
    ../SYS/src/: delay.c
  group Rf
    ../RF/src/: pan3028.c radio.c pan3028_port.c
  group Doc
    ../: readme.txt
software components: CMSIS:CORE 6.1.0
