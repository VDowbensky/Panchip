# IAR project Project.ewp, settings and files
configuration Release (ARM)
  General.OGChipSelectEditMenu: Default None
  General.RTConfigPath2: $TOOLKIT_DIR$\inc\c\DLib_Config_Full.h
  General.CoreVariant: 35
  General.FPU2: 0
  ICCARM.CCDefines: NDEBUG
  ICCARM.CCIncludePath2: ..\USER\inc; ..\..\..\Libraries\inc; ..\..\..\IdeSupport\EWARM; ..\SYS\inc; ..\OLED\inc; ..\RF\inc
  ICCARM.CCOptLevel: 3
  ICCARM.CCOptStrategy: 0
  ICCARM.IccLang: 0
  OBJCOPY.OOCOutputFile: Project.hex
  ILINK.IlinkOutputFile: Project.out
  ILINK.IlinkIcfFile: $TOOLKIT_DIR$\config\linker\WHXY\CW32W031.icf
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration debug (ARM)
  as the first configuration, except:
  General.CoreVariant: 38
  OBJCOPY.OOCOutputFile: template.srec
  group Doc
    ../: readme.txt
  group Driver
    ../../../Libraries/src/: cw32w031_adc.c cw32w031_flash.c cw32w031_gpio.c cw32w031_gtim.c cw32w031_rcc.c cw32w031_spi.c cw32w031_systick.c cw32w031_uart.c
  group Oled
    ../OLED/src/: display.c oled.c
  group Rf
    ../RF/src/: pan3028.c pan3028_port.c radio.c
  group Startup
    ../../../IdeSupport/EWARM/: startup_cw32w031.s
    ../../../Libraries/src/: system_cw32w031.c
  group Sys
    ../SYS/src/: delay.c
  group User
    ../USER/src/: cw32w031bios.c interrupts_cw32w031.c main.c
