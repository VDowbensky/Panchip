# IAR project project.ewp, settings and files
configuration Release (ARM)
  General.OGChipSelectEditMenu: Default None
  General.RTConfigPath2: $TOOLKIT_DIR$\inc\c\DLib_Config_Full.h
  General.CoreVariant: 35
  General.FPU2: 0
  ICCARM.CCDefines: NDEBUG
  ICCARM.CCIncludePath2: ..\USER\inc; ..\..\..\..\Libraries\inc; ..\..\..\..\Utilities
  ICCARM.CCOptLevel: 3
  ICCARM.CCOptStrategy: 0
  ICCARM.IccLang: 0
  OBJCOPY.OOCOutputFile: project.hex
  ILINK.IlinkOutputFile: project.out
configuration debug (ARM)
  as the first configuration, except:
  General.CoreVariant: 38
  OBJCOPY.OOCOutputFile: template.srec
  group Doc
    ../: readme.txt
  group Driver
    ../../../../Libraries/src/: cw32w031_adc.c cw32w031_atim.c cw32w031_flash.c cw32w031_gpio.c cw32w031_gtim.c cw32w031_rcc.c cw32w031_uart.c
  group Startup
    ../../../../IdeSupport/EWARM/: startup_cw32w031.s
    ../../../../Libraries/src/: system_cw32w031.c
  group User
    ../USER/src/: interrupts_cw32w031.c main.c
  group Utilities
    ../../../../Utilities/: cw32w031rxux_startkit.c
