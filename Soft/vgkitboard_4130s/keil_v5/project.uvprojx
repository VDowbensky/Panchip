# Keil uVision project project.uvprojx, settings and files
target project_AT (5060750::V5.06 update 6 (build 750)::.\ARMCC)
  device: -AT32F413RCT7 ArteryTek
  pack: ArteryTek.AT32F413_DFP.2.1.3
  cpu: IRAM(0x20000000,0x8000) IROM(0x08000000,0x40000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ELITTLE
  output: VGKitBoard_4130NS1_AT_V13 +hex
  c flags: Optim=1 OneElfS=1 uC99=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: STM32F10X_HD,USE_STDPERIPH_DRIVER
  c include: ..\project;..\core;..\STM32F10x_FWLib\inc;..\peripheral;..\app;..\radio
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x40000
  memory RVCT9: RAM 0x20000000 size 0x8000
  group project
    ../project/: main.c stm32f10x_it.c system_stm32f10x.c
  group peripheral
    ../peripheral/: myUart.c sys.c myADC.c myInputCapture.c myUart3.c
  group core
    ../CORE/: core_cm3.c startup_stm32f10x_hd.s
  group FWLIB
    ../STM32F10x_FWLib/src/: misc.c stm32f10x_adc.c stm32f10x_bkp.c stm32f10x_can.c stm32f10x_cec.c stm32f10x_crc.c stm32f10x_dac.c stm32f10x_dbgmcu.c stm32f10x_dma.c stm32f10x_exti.c stm32f10x_flash.c stm32f10x_fsmc.c stm32f10x_gpio.c stm32f10x_i2c.c stm32f10x_iwdg.c stm32f10x_pwr.c stm32f10x_rcc.c stm32f10x_rtc.c stm32f10x_sdio.c stm32f10x_spi.c stm32f10x_tim.c stm32f10x_usart.c stm32f10x_wwdg.c
  group app
    ../APP/: led.c key.c stmflash.c ReadKey.c myLcd.c myTim.c
    ../app/: crc8.c eventUnit.c myDisplayUnit.c myFlashData.c
  group radio
    ../radio/: myRadio.c myRadio_gpio.c pan3029.c pan3029_port.c radio.c
target project_ST (5060960::V5.06 update 7 (build 960)::.\ARMCC)
  device: STM32F103RC STMicroelectronics
  pack: Keil.STM32F1xx_DFP.2.4.1
  cpu: IRAM(0x20000000,0x0000C000) IROM(0x08000000,0x00040000) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: VGKitBoard_4130NS1_ST_V13 +hex
  AfterMake: fromelf.exe --bin --output .\Listings\@L.bin !L
  c flags: Optim=1 OneElfS=1 uC99=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: STM32F10X_HD,USE_STDPERIPH_DRIVER,__SPI_SOFT_3LINE
  c include: as above
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x40000
  memory RVCT9: RAM 0x20000000 size 0xc000
target project_AT_APP (5060750::V5.06 update 6 (build 750)::.\ARMCC)
  device: -AT32F413RCT7 ArteryTek
  pack: ArteryTek.AT32F413_DFP.2.1.3
  cpu: as above
  output: VGKitBoard_4130NS1_AT_APP_V13 +hex
  AfterMake: fromelf.exe --bin --output .\Listings\@L.bin !L
  c flags: Optim=1 OneElfS=1 uC99=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: STM32F10X_HD,USE_STDPERIPH_DRIVER,BOOTLOADER_APP
  c include: as above
  library: MicroLIB
  memory RVCT4: ROM 0x800c800 size 0x40000
  memory RVCT9: RAM 0x20000000 size 0x8000
target project_ST_APP (5060750::V5.06 update 6 (build 750)::.\ARMCC)
  device: STM32F103RC STMicroelectronics
  pack: Keil.STM32F1xx_DFP.2.4.1
  cpu: as above
  output: VGKitBoard_4130NS1_ST_APP_V13 +hex
  AfterMake: fromelf.exe --bin --output .\Listings\@L.bin !L
  c flags: Optim=1 OneElfS=1 uC99=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: STM32F10X_HD,USE_STDPERIPH_DRIVER,BOOTLOADER_APP,__SPI_SOFT_3LINE
  c include: as above
  library: MicroLIB
  memory RVCT4: ROM 0x800c800 size 0x40000
  memory RVCT9: RAM 0x20000000 size 0xc000
