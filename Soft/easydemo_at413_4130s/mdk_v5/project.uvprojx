# Keil uVision project project.uvprojx, settings and files
target project (5060960::V5.06 update 7 (build 960)::.\ARMCC)
  device: -AT32F413RCT7 ArteryTek
  pack: ArteryTek.AT32F413_DFP.2.1.3
  cpu: IRAM(0x20000000,0x8000) IROM(0x08000000,0x40000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ELITTLE
  output: easydemo_at413_4130S +hex
  c flags: Optim=1 OneElfS=1 uC99=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: AT32F413RCT7,USE_STDPERIPH_DRIVER,AT_START_F413_V1
  c include: ..\libraries\drivers\inc;..\libraries\cmsis\cm4\core_support;..\libraries\cmsis\cm4\device_support;..\inc;..\at32f413_board;..\radio
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x40000
  memory RVCT9: RAM 0x20000000 size 0x8000
  group user
    ../src/: at32f413_clock.c at32f413_int.c main.c
  group bsp
    ../at32f413_board/: at32f413_board.c
  group firmware
    ../libraries/drivers/src/: at32f413_acc.c at32f413_adc.c at32f413_bpr.c at32f413_can.c at32f413_crc.c at32f413_crm.c at32f413_debug.c at32f413_dma.c at32f413_exint.c at32f413_flash.c at32f413_gpio.c at32f413_i2c.c at32f413_misc.c at32f413_pwc.c at32f413_rtc.c at32f413_sdio.c at32f413_spi.c at32f413_tmr.c at32f413_usart.c at32f413_usb.c at32f413_wdt.c at32f413_wwdt.c
  group cmsis
    ../libraries/cmsis/cm4/device_support/: system_at32f413.c
    ../libraries/cmsis/cm4/device_support/startup/mdk/: startup_at32f413.s
  group readme
    ../: readme.txt
  group radio
    ../radio/: myRadio.c myRadio_gpio.c pan3029.c pan3029_port.c radio.c
