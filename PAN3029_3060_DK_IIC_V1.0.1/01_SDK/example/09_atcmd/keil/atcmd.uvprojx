# Keil uVision project atcmd.uvprojx, settings and files
target atcmd (5060960::V5.06 update 7 (build 960)::.\ARMCC)
  device: HC32F460JEUA HDSC
  pack: HDSC.HC32F460.1.0.8
  cpu: IRAM(0x1FFF8000,0x2F000) IRAM2(0x200F0000,0x1000) IROM(0x00000000,0x80000) IROM2(0x03000C00,0x003FC) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ELITTLE
  output: atcmd +hex
  c flags: Optim=4 OneElfS=1 uC99=1 v6Lang=1 v6LangP=1
  c define: __DEBUG,HC32F460,USE_DEVICE_DRIVER_LIB,AT_USING_SERVER
  c misc: --diag_suppress=186,66
  c include: ..\source;..\..\..\mcu\common;..\..\..\radio;..\..\..\mcu\hc32_driver\inc;..\middleware\atcmd;..\middleware\atcmd\inc;..\middleware\fifo;..\..\..\mcu\bsp
  library: MicroLIB
  memory RVCT4: ROM 0x0 size 0x80000
  memory RVCT5: ROM 0x3000c00 size 0x3fc
  memory RVCT9: RAM 0x1fff8000 size 0x2f000
  memory RVCT10: RAM 0x200f0000 size 0x1000
  link misc: --keep=*Handler
  group common
    ../../../mcu/common/: startup_hc32f460.s system_hc32f460.c utilities.c
  group hc32_driver
    ../../../mcu/hc32_driver/src/: hc32f460_utility.c hc32f460_pwc.c hc32f460_interrupts.c hc32f460_clk.c hc32f460_icg.c hc32f460_efm.c hc32f460_sram.c hc32f460_spi.c hc32f460_gpio.c hc32f460_exint_nmi_swi.c hc32f460_usart.c hc32f460_timer4_cnt.c hc32f460_timer4_oco.c hc32f460_timer4_pwm.c hc32f460_timer6.c hc32f460_timera.c
  group radio
    ../../../radio/: pan_rf.c
  group middleware/atcmd
    ../middleware/atcmd/src/: at_base_cmd.c at_server.c at_utils.c
  group middleware/fifo
    ../middleware/fifo/: fifo.c
  group source
    ../../../mcu/bsp/: bsp.c
    ../source/: pn_atcmd.c main.c
software components: CMSIS:CORE 5.3.0
